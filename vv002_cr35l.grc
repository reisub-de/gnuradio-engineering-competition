<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vv002_cr35l</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_file</value></param>
<param><key>value</key><value>"tp1.ts"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_file</value></param>
<param><key>value</key><value>"gr_tp19.dat"</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>blocksize</key><value>38688</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>output_file</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>input_file</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>blocksize</key><value>64800/8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>32768/128</value></param>
<param><key>input_size</key><value>32768</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dtv_dvb_bbheader_bb</key>
<param><key>id</key><value>dtv_dvb_bbheader_bb_0</value></param>
<param><key>mode</key><value>INPUTMODE_HIEFF</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0_0</value></param>
<param><key>rate1</key><value>C3_5</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_cellinterleaver_cc_0</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>fecblocks</key><value>202</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_framemapper_cc</key>
<param><key>id</key><value>dtv_dvbt2_framemapper_cc_0</value></param>
<param><key>rate</key><value>C3_5</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fecblocks</key><value>202</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbt2_interleaver_bb_0</value></param>
<param><key>rate</key><value>C3_5</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbt2_interleaver_bb_0_0</value></param>
<param><key>rate</key><value>C3_5</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbt2_modulator_bc_0</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dtv_dvbt2_p1insertion_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dtv_dvbt2_pilotgenerator_cc_0</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_8_0_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvb_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>dtv_dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>dtv_dvbt2_p1insertion_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbheader_bb_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0_0</source_block_id><sink_block_id>dtv_dvbt2_interleaver_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dtv_dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_pilotgenerator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_interleaver_bb_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_interleaver_bb_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_modulator_bc_0</source_block_id><sink_block_id>dtv_dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_pilotgenerator_cc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
